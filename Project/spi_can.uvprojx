# Keil uVision project spi_can.uvprojx, settings and files
target dog_spi2can (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32E103C8 GigaDevice
  pack: GigaDevice.GD32E10x_DFP.1.0.3
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: spi_can +hex
  AfterMake: fromelf.exe --bin  ./Objects/@L.axf  --output  ./bin/@L.bin
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32E10X,GD32E103R_START
  c include: ..\Libraries\CMSIS;..\Libraries\CMSIS\GD\GD32E10x\Include;..\Libraries\GD32E10x_standard_peripheral\Include;..\User;..\BSP
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ../Libraries/CMSIS/GD/GD32E10x/Source/: system_gd32e10x.c
    ../Libraries/CMSIS/GD/GD32E10x/Source/ARM/: startup_gd32e10x.s
  group Libraries
    ../Libraries/GD32E10x_standard_peripheral/Source/: gd32e10x_adc.c gd32e10x_bkp.c gd32e10x_can.c gd32e10x_crc.c gd32e10x_ctc.c gd32e10x_dac.c gd32e10x_dbg.c gd32e10x_dma.c gd32e10x_exmc.c gd32e10x_exti.c gd32e10x_fmc.c gd32e10x_fwdgt.c gd32e10x_gpio.c gd32e10x_i2c.c gd32e10x_misc.c gd32e10x_pmu.c gd32e10x_rcu.c gd32e10x_rtc.c gd32e10x_spi.c gd32e10x_timer.c gd32e10x_usart.c gd32e10x_wwdgt.c
  group BSP
    ../BSP/: BSP_Config.c bsp_can.c bsp_delay.c bsp_gpio.c bsp_spi.c bsp_timer.c bsp_uart.c bsp_exit.c bsp_dma.c
  group User
    ../User/: gd32e10x_it.c gd32e10x_it.h gd32e10x_libopt.h leg_message.h math_ops.h main.c math_ops.c main.cpp
